# Keil uVision project sdadc.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F373V8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: sdadc
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, USE_STM32373C_EVAL, STM32F37X
  c include: ..\user;..\stm32f3;..\lib\inc;..\lib\src;..\drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_stm32f37x.s
    ../stm32f3/: stm32f37x_it.c system_stm32f37x.c
  group drive
    ../drive/: uart.c sdadc.c systick.c time.c exit.c
  group user
    ./: main.c
  group lib
    ../lib/src/: stm32f37x_usart.c stm32f37x_gpio.c stm32f37x_sdadc.c stm32f37x_exti.c stm32f37x_misc.c stm32f37x_rcc.c stm32f37x_syscfg.c stm32f37x_pwr.c stm32f37x_tim.c stm32f37x_spi.c stm32f37x_adc.c stm32f37x_i2c.c
